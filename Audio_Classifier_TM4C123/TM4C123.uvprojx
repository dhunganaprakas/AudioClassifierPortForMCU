# Keil uVision project TM4C123.uvprojx, settings and files
target TM4C123 (6180000::V6.18::ARMCLANG)
  device: TM4C1230C3PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x003000) IROM(0x00000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C129
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: Source.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
